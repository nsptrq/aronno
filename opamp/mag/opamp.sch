v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmoscs.sym} -50 -40 0 0 {name=x1}
C {nmoscs.sym} -50 70 0 0 {name=x2}
C {pmosout.sym} 380 -40 2 0 {name=x3}
C {nmosout.sym} 380 60 2 0 {name=x4}
C {devices/lab_pin.sym} 230 -70 0 0 {name=p1 sig_type=std_logic lab=vout}
C {devices/lab_pin.sym} 230 -50 0 0 {name=p2 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 230 -30 0 0 {name=p3 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 230 -10 0 0 {name=p4 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 230 40 0 0 {name=p5 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 230 60 0 0 {name=p6 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 230 80 0 0 {name=p7 sig_type=std_logic lab=vout}
C {devices/lab_pin.sym} 100 -70 2 0 {name=p8 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 100 -50 2 0 {name=p9 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 100 -30 2 0 {name=p10 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 100 -10 2 0 {name=p11 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 100 40 2 0 {name=p12 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 100 60 2 0 {name=p13 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 100 80 2 0 {name=p14 sig_type=std_logic lab=rs}
C {devices/lab_pin.sym} 100 100 2 0 {name=p15 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 530 -30 2 0 {name=p16 sig_type=std_logic lab=vip}
C {devices/lab_pin.sym} 530 -10 2 0 {name=p17 sig_type=std_logic lab=vin}
C {devices/iopin.sym} -280 -190 2 0 {name=p18 lab=vip}
C {devices/iopin.sym} -280 -150 2 0 {name=p19 lab=vin}
C {devices/iopin.sym} -280 -110 2 0 {name=p20 lab=vout}
C {devices/iopin.sym} -280 -70 2 0 {name=p21 lab=rs}
C {devices/iopin.sym} -280 -30 2 0 {name=p22 lab=vdd}
C {devices/iopin.sym} -280 10 2 0 {name=p23 lab=gnd}
